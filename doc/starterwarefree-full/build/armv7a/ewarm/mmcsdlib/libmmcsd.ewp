# IAR project libmmcsd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\hw; ..\..\..\..\mmcsdlib\include; ..\..\..\..\include\armv7a; ..\..\..\..\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: utils.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../mmcsdlib/: hs_mmcsdlib.c mmcsd_proto.c
