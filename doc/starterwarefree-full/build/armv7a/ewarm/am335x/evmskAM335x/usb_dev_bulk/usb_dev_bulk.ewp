# IAR project usb_dev_bulk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\include\armv7a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_dev_bulk.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_dev_bulk.out
  ILINK.IlinkIcfFile: usb_dev_bulk.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Debug\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Debug\usblib.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Release\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Release\usblib.a
  group (top)
    ../../../../../../examples/evmskAM335x/usb_dev_bulk/: usb_bulk_structs.c usb_dev_bulk.c ustdlib.c
